# Keil uVision project RMA-MotorStack.uvprojx, settings and files
target RMA-MotorStack (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RMA-MotorStack +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../App;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329 --library_type=microlib
  group Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f427xx.s gpio.c spi.c usart.c tim.c can.c adc.c dma.c sdio.c fatfs.c sd_diskio.c bsp_driver_sd.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group BSP
    ../BSP/: bsp_imu.c bsp_uart.c bsp_can.c bsp_oled.c sd_card.c
  group App
    ../App/: app_imu.c app_motor.c app_rc.c app_uwb.c app_display.c app_c620.c
  group Drivers/HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c stm32f4xx_ll_sdmmc.c
  group Middlewares/USB_Device
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FatFs
    ../Middlewares/ST/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/ST/Third_Party/FatFs/src/option/: unicode.c
software components: CMSIS:CORE 4.1.0
